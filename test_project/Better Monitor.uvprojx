# Keil uVision project Better Monitor.uvprojx, settings and files
target DryBath (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uCOSDemo +hex
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\Source\APP;.\Source\BSP;.\Source\uCOS-II\Source;.\Source\uCOS-II\uC-CPU;.\Source\uCOS-II\uC-LIB;.\Source\uCOS-II\Ports;.\Source\uCGUI\Config;.\Source\uCGUI\emWinDemo;.\Source\uCGUI\inc;.\Source\uCGUI\LCDDriver;.\Source\uCGUI\uCGUIDemo;.\Source\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Source\Libraries\CMSIS\Core\CM3;.\Source\APP\HMI;.\Source\CH374;.\Source\fatfs;.\Source\STM32_USB-FS-Device_Driver\inc;.\Source\usb_mass
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./Source/Startup/: cortexm3_macro.s startup_stm32f10x_hd.s
  group APP
    ./Source/APP/: app.c app_cfg.h includes.h os_cfg.h stm32f10x_it.c stm32f10x_conf.h usart_printf.c nrf905.c com.c sim900a.c hmi.c eeprom.c common.c udisk_ch374.c user_configure.c main.c board_init.c systick.c battery.c adc.c
  group BSP
    ./Source/BSP/: bsp.c bsp_nand.c bsp_led.c
  group std_lib
    ./Source/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_exti.c misc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_dac.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_can.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_rcc.c stm32f10x_tim.c
  group uCOS-Ⅱ/Ports
    ./Source/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group uCOS-II/CPU
    ./Source/uCOS-II/uC-CPU/: cpu_a.asm cpu_def.h cpu.h
  group uCOS-Ⅱ/Source
    ./Source/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group CMSIS
    ./Source/Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group HMI
    ./Source/APP/HMI/: DefineID.c hmi_driver.c hmi_user_uart.c
  group FatFS
    ./Source/fatfs/: diskio.c ff.c
  group USB-Mass
    ./Source/usb_mass/: mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_hw.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USB-FS-Device-Driver
    ./Source/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group CH374
    ./Source/CH374/: bsp_CH374.C bsp_CH374.h CH374HFM.H CH374HFM.LIB
target uCOSDemo_0x40000 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: as above
  output: uCOSDemo_0x40000 +hex
  c define: DEF_ROM_0X40000
  c include: .\Source\APP;.\Source\BSP;.\Source\FWLib;.\Source\Startup;.\Source\uCOS-II\Source;.\Source\uCOS-II\uC-CPU;.\Source\uCOS-II\uC-LIB;.\Source\uCOS-II\Ports;.\Source\uCGUI\Config;.\Source\uCGUI\emWinDemo;.\Source\uCGUI\inc;.\Source\uCGUI\LCDDriver;.\Source\uCGUI\uCGUIDemo;.\Source\FWLib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
